# Keil uVision project Test8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Test8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.h main.c port.h lcd.c lcd.h dht.c dht.h delay.c delay.h uart.c uart.h interrupt.c interrupt.h STARTUP.A51 ADC0804.h ADC0804.c
    C:/Keil_v5/C51/LIB/: C51C.LIB
